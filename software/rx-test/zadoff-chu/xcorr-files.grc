options:
  parameters:
    author: techtile
    generate_options: qt_gui
    id: xcorr_files
    output_language: python
    title: xcorr files
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: seq_len*2
  states: {}
- name: number_of_points_multiplier
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: seq
  id: variable
  parameters:
    value: ZC.generate(7,seq_len)
  states: {}
- name: seq_len
  id: variable
  parameters:
    value: '353'
  states: {}
- name: throtle_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: ZC
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np

      def generate(u=1, seq_length=53, q=0):

          """
          Generate a Zadoff-Chu (ZC) sequence.
          Parameters
          ----------
          u : int
              Root index of the the ZC sequence: u>0.
          seq_length : int
              Length of the sequence to be generated. Usually a prime number:
              u<seq_length, greatest-common-denominator(u,seq_length)=1.
          q : int
              Cyclic shift of the sequence (default 0).
          Returns
          -------
          zcseq : 1D ndarray of complex floats
              ZC sequence generated.
              
         To still put DC to 0, 
         we interleave the ZC sequence with zeros.
       
          """
          
          for el in [u,seq_length,q]:
              if not float(el).is_integer():
                  raise ValueError('{} is not an integer'.format(el))
          if u<=0:
              raise ValueError('u is not stricly positive')
          if u>=seq_length:
              raise ValueError('u is not stricly smaller than seq_length')
              
          if np.gcd(u,seq_length)!=1:
              raise ValueError('the greatest common denominator of u and seq_length is not 1')
              

          cf = seq_length%2
          n = np.arange(seq_length)
          zcseq = np.exp( -1j * np.pi * u * n * (n+cf+2.0*q) / seq_length)
          
          return zcseq
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1_1_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/techtile-ursp/NI-B210-Sync/software/results/250e3Sps/usrp_samples_31DBE03_0.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile-ursp/NI-B210-Sync/software/results/250e3Sps/usrp_samples_31DBE03_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile-ursp/NI-B210-Sync/software/results/250e3Sps/usrp_samples_31DEA71_0.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile-ursp/NI-B210-Sync/software/results/250e3Sps/usrp_samples_31DEA71_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: throtle_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: throtle_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: throtle_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: throtle_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: seq
    vlen: seq_len
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: seq_len
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: seq_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (0,0)
    name: '"USRP1"'
    size: seq_len*number_of_points_multiplier
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (3,0)
    name: '"USRP1 vs USRP2"'
    size: seq_len*number_of_points_multiplier
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (1,0)
    name: '"USRP2"'
    size: seq_len*number_of_points_multiplier
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (4,0)
    name: '"USRP2+ZC"'
    size: int(500e3*5)
    srate: samp_rate
    type: float
  states: {}
- name: xcorr_0
  id: xcorr
  parameters:
    fft_len: fft_len
  states: {}
- name: xcorr_0_0
  id: xcorr
  parameters:
    fft_len: fft_len
  states: {}
- name: xcorr_0_1
  id: xcorr
  parameters:
    fft_len: fft_len
  states: {}
- name: xcorr_0_1_0
  id: xcorr
  parameters:
    fft_len: fft_len
  states: {}

connections:
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_complex_to_mag_1_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_complex_to_mag_1_1, '0', qtgui_time_sink_x_0_0_0_0_1, '0']
- [blocks_complex_to_mag_1_1_0, '0', qtgui_time_sink_x_0_0_0_0_1_0, '0']
- [blocks_file_source_0, '0', xcorr_0, '0']
- [blocks_file_source_0_0, '0', xcorr_0, '1']
- [blocks_file_source_0_0, '0', xcorr_0_0, '0']
- [blocks_file_source_0_0_0, '0', xcorr_0_0, '1']
- [blocks_file_source_0_0_0, '0', xcorr_0_1, '0']
- [blocks_file_source_0_0_0, '0', xcorr_0_1_0, '0']
- [blocks_file_source_0_0_0_0, '0', xcorr_0_1, '1']
- [blocks_throttle_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_throttle_0_0, '0', blocks_complex_to_mag_1_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_complex_to_mag_1_1, '0']
- [blocks_throttle_0_0_0_0, '0', blocks_complex_to_mag_1_1_0, '0']
- [blocks_vector_source_x_0_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', xcorr_0_1_0, '1']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [xcorr_0, '0', blocks_throttle_0, '0']
- [xcorr_0_0, '0', blocks_throttle_0_0, '0']
- [xcorr_0_1, '0', blocks_throttle_0_0_0, '0']
- [xcorr_0_1_0, '0', blocks_throttle_0_0_0_0, '0']

metadata:
  file_format: 1
